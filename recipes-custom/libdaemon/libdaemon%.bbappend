do_configure_prepend() {
	           export ac_cv_func_getpgrp_void=no \
               export ac_cv_func_setpgrp_void=yes \
               export ac_cv_func_memcmp_working=yes \
               export rb_cv_binary_elf=no \
               export rb_cv_negative_time_t=no
}