SRC_URI_append_libc-uclibc = " file://replace_getrpcbynumber_r.patch"