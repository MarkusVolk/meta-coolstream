CFLAGS_append += "-Wno-implicit-fallthrough -Wno-format-truncation"
