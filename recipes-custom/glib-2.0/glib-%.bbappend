DEPENDS_append += "intltool gettext"