CFLAGS_append += "-D_GNU_SOURCE"