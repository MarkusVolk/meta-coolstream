DEPENDS_append += "virtual/libstb-hal"

INSANE_SKIP_${PN} += "file-rdeps"
