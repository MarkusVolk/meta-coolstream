CFLAGS_append += "-lnfsidmap"