IMAGE_INSTALL_append += " \
					cs-drivers-hd2 \
						"