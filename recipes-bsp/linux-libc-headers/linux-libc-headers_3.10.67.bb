COMPATIBLE_MACHINE = "coolstream-hd2"

require linux-libc-headers.inc

SRC_URI = " \
	https://www.kernel.org/pub/linux/kernel/v3.x/linux-3.10.67.tar.xz \
"

SRC_URI[md5sum] = "0fe80b40449ccf988d5b0745af128429"
SRC_URI[sha256sum] = "2a16dee82833f89ef88837f4227fdc22e90c08a6c5982692e3d8bd410c1b0f95"
