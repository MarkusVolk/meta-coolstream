COMPATIBLE_MACHINE = "coolstream-hd2"

require linux-libc-headers.inc

SRC_URI = " \
	https://www.kernel.org/pub/linux/kernel/v3.x/linux-3.10.27.tar.xz \
"

SRC_URI[md5sum] = "4edaaea57dc940969c54ac249e49f7e7"
SRC_URI[sha256sum] = "7f7b3b55d31f5194b86e8c152ee35986f563e5d073069eb878bcd4b3a676557e"
