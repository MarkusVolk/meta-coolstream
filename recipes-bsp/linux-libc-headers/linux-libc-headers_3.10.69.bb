COMPATIBLE_MACHINE = "coolstream-hd2"

require linux-libc-headers.inc

SRC_URI = " \
	https://www.kernel.org/pub/linux/kernel/v3.x/linux-3.10.69.tar.xz \
"

SRC_URI[md5sum] = "512334d86e94ade6b97a490adace54e0"
SRC_URI[sha256sum] = "2ce72f1d6290b64514cc7ba10cde4c9331add7a0d7421b9a861cb8a0dbb5a492"
