require linux-libc-headers.inc

SRC_URI_coolstream-hd2 = " \
	https://www.kernel.org/pub/linux/kernel/v3.x/linux-3.10.107.tar.xz \
"

SRC_URI[md5sum] = "a2996cef75a0acbaae2140169d1f58c4"
SRC_URI[sha256sum] = "948ae756ba90b3b981fb8245789ea1426d43c351921df566dd5463171883edc3"

